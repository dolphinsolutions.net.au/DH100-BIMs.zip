Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-07-01T15:19:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 01 15:19:47 2024 * Host: Administrator * Database: C:\Users\Lenovo\AppData\Local\Temp\{C7A0116E-D6FD-4B70-98CB-D1B778041C45}\ifc * Database version: 5507 * Database creation date: Mon Jul 01 15:19:45 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 01 15:19:46 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 01 15:19:46 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcDoor: DH100, DH100:DH100:202044
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Satin_suffix_.5PowderCoated_.6CeramicCoated
OverallHeight: 49.4549 mm; OverallWidth: 172.6 mm
Pset_DoorCommon - Reference: DH100; IsExternal: no
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DoorLeverHandleSet
